## config/boards/arm/dimple/Kconfig.board
```kconfig
# Copyright (c) 2022 LAZYDESIGNERS
# SPDX-License-Identifier: MIT

config BOARD_DIMPLE
	bool "dimple"
	depends on SOC_NRF52840_QIAA
```
